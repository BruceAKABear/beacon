# Repository BruceAKABear/beacon

## KiCad design ch573beacon.kicad_pcb

Parts:
AE1: Antenna_Chip; CA-03
BT1: Battery; BatteryHolder_Keystone_1058_1x2032
C1, C2, C7: 2.2uf; C_0402_1005Metric
C3, C4, C5, C6, C8, C10: 0.1uf; C_0402_1005Metric
C9: C_0402_1005Metric
C11: 10uf; C_0402_1005Metric
D1: D; D_0402_1005Metric
D2: LED; LED_0402_1005Metric
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12
JP1: Jumper_3_Bridged12; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: 22uh; L_Taiyo-Yuden_MD-2020
R1, R2: 4.7k; R_0402_1005Metric
R3, R9: 1k; R_0402_1005Metric
R4, R5: 10k; R_0402_1005Metric
R6, R7: 5.1k; R_0402_1005Metric
R8: 2k; R_0402_1005Metric
SW1: SW_Push; bt-342
U1: BH1750FVI
U2: ME6216A33M3G; SOT-23
U3: CH573F; QFN-28-1EP_4x4mm_P0.45mm_EP2.4x2.4mm
U4: SHT31-DIS; Sensirion_DFN-8-1EP_2.5x2.5mm_P0.5mm_EP1.1x1.7mm
U5: TP4054; SOT-23-5
Y1: Crystal; Crystal_SMD_2012-2Pin_2.0x1.2mm_HandSoldering
Y2: Crystal_GND24; Crystal_SMD_2016-4Pin_2.0x1.6mm

Connections:
+5V: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), JP1.2 (C)
BAT: BT1.1 (+), C11.1, D1.2 (A), U5.3 (VBAT)
BOOT: C10.2, SW1.1, U3.17 (PB22)
CC1: J1.A5 (CC1), R6.1
CC2: J1.B5 (CC2), R7.1
CHARG: C9.1, JP1.3 (B), R9.1, U5.4 (VDD)
D+: J1.A6 (D+), J1.B6 (D+), U3.12 (PB11)
D-: J1.A7 (D-), J1.B7 (D-), U3.13 (PB10)
DIRECT: C3.1, D1.1 (K), JP1.1 (A), U2.3 (VIN)
GND: BT1.2 (-), C1.1, C2.1, C3.2, C4.2, C5.2, C6.1, C7.1, C8.2, C9.2, C10.1, C11.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), R6.2, R7.2, R8.2, SW1.2, U1.2 (ADDR), U1.3 (GND), U2.1 (VSS), U3.29 (GND), U4.2 (ADDR), U4.7 (R), U4.8 (VSS), U4.9 (VSS), U5.2 (GND), Y2.2, Y2.4
unnamed: AE1.2 (PCB_Trace), U3.21 (ANT)
unnamed: C1.2, L1.1, U3.3 (VDCID)
unnamed: C5.1, R3.2, U1.5 (DVI)
unnamed: C6.2, U3.22 (VDCIA)
unnamed: C7.2, U3.20 (VINTA)
unnamed: D2.1 (K), U5.1 (STAT)
unnamed: D2.2 (A), R9.2
unnamed: L1.2, U3.4 (VSW)
unnamed: R8.1, U5.5 (PROG)
unnamed: U3.1 (PA11), Y1.1
unnamed: U3.2 (PA10), Y1.2
unnamed: U3.18 (X32MO), Y2.1
unnamed: U3.19 (X32MI), Y2.3
SCL_BH: R1.2, U1.6 (SCL), U3.6 (PA8)
SCL_SHT: R5.2, U3.8 (PB15), U4.4 (SCL)
SDA_BH: R2.2, U1.4 (SDA), U3.7 (PA9)
SDA_SHT: R4.2, U3.9 (PB14), U4.1 (SDA)
VCC: C2.2, C4.1, C8.1, R1.1, R2.1, R3.1, R4.1, R5.1, U1.1 (VCC), U2.2 (VOUT), U3.5 (VIO33), U4.5 (VDD)

Notes on the sheet:
按住后上电将会进入USB下载模式
ADDR下拉 地址为0x23
ADDR下拉地址为0x44
32Mhz 10ppm 2016
当电池充满以后指示灯亮 2k 电流360ma

Board: 2 copper layers, 34.0 x 34.0 mm, 37 parts (1 on the bottom side), 28 nets.

Other parts of the board:
kibuzzard-64141A9C: G***; kibuzzard-64141A9C
kibuzzard-64142EB1: G***; kibuzzard-64142EB1

## Commit log

2023-03-14 init
